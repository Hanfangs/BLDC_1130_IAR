# IAR project BLDC_1130.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: C:\Users\Hanfang Su\Desktop\科研\Mortor\BLDC_1130_IAR\Code\Start\Device; C:\Users\Hanfang Su\Desktop\科研\Mortor\BLDC_1130_IAR\Code\StdPeriph_Driver\inc; C:\Users\Hanfang Su\Desktop\科研\Mortor\BLDC_1130_IAR\Code\System\inc; C:\Users\Hanfang Su\Desktop\科研\Mortor\BLDC_1130_IAR\Code\User\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLDC_1130.hex
  ILINK.IlinkOutputFile: BLDC_1130.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f103x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Start
    Code/Start/Device/: startup_stm32f10x_md.s system_stm32f10x.c
  group StdPeriph_Driver
    Code/StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    Code/System/src/: Analog.c BLDC.c GPIO_Init.c PI_Cale.c SysConfig.c Timer.c Timer_ISR.c USART.c
  group User
    Code/User/src/: main.c stm32f10x_it.c

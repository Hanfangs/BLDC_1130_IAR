<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\BLDC_1130.ewp</path>
    </project>
    <batchBuild />
</workspace>
